FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-1.-support-linux-openssl-instead-of-the-static-libra.patch"

